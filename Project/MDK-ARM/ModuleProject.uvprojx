# Keil uVision project ModuleProject.uvprojx, settings and files
target Templetes (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ModuleProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,STM32F10X_MD
  c include: ..\..\Driver\CMSIS\Device\ST\STM32F1xx\Include;..\..\Driver\STM32F1xx_HAL_Driver\Inc;..\..\Driver\CMSIS\Include;..\..\Driver\BSP\Inner;..\..\Driver\BSP\Exter;..\..\Driver\BSP\Apply;..\..\Driver\System;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../../Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../../User/: stm32f1xx_it.c system_stm32f1xx.c main.c
  group Driver/BSP/Inner
    ../../Driver/BSP/Inner/timer/: Btim.c
    ../../Driver/BSP/Inner/rtc/: MyRTC.c MyAlarm.c SecondWatch.c
    ../../Driver/BSP/Inner/sleep/: timingSleep.c
    ../../Driver/BSP/Inner/exti/: GPIOExti.c
  group Driver/BSP/Exter
    ../../Driver/BSP/Exter/beep/: Beep.c
    ../../Driver/BSP/Exter/encoder/: Encoder.c
    ../../Driver/BSP/Exter/key/: Key.c
    ../../Driver/BSP/Exter/led/: LED.c
    ../../Driver/BSP/Exter/oled/: OLED.c OnceDis.c
    ../../Driver/BSP/Exter/max30102/: heart_Spo2.c max30102.c
  group Driver/BSP/Apply
    ../../Driver/BSP/Apply/Menu/: Menu.c
  group Driver/stm32F1xx_Hal_Driver
    ../../Driver/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Driver/System
    ../../Driver/System/delay/: delay.c
    ../../Driver/System/usart/: usart.c
    ../../Driver/System/sys/: sys.c
  group Readme
    ../../Readme/: Readme.txt test.txt
